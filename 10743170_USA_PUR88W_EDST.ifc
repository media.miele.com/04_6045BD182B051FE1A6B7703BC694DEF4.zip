Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 2840fc91-5152-4725-b2d5-a6f02d5ab460, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-12T10:30:59+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 10743170_USA_PUR88W_EDST:28428654_USA_10743170_PUR88W_EDST, (2)
In: Default
Type - Material: z_Miele_Design_Alusilver, z_Miele_Design_CLST, z_Miele_Connection_ExhaustAir, z_Miele_Connection_Electric, z_Miele_Design_Glass, z_Miele_Design_GRGR
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 748 mm; Depth: 500 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 28428654_USA_10743170_PUR88W_EDST; sets with these values: 2
